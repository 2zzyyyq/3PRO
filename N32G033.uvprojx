# Keil uVision project N32G033.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: N32G033K8 Nsingtech
  pack: Nsingtech.N32G033_DFP.0.1.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: N32G033 +hex
  AfterMake: E:\N32HEX\N32.bat
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\n32g033_std_periph_driver\inc;.\n32g033_std_periph_driver\src;.\CMSIS\core;.\CMSIS\device\startup;.\USER\src;.\USER\inc;.\CMSIS\device;.\DVI\src;.\USER\src;.\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group STARTUP
    ./CMSIS/device/startup/: startup_n32g033.s
  group CMSIS
    ./CMSIS/device/: system_n32g033.c
  group FLWB
    ./n32g033_std_periph_driver/src/: misc.c n32g033_adc.c n32g033_comp.c n32g033_dbg.c n32g033_dma.c n32g033_exti.c n32g033_flash.c n32g033_gpio.c n32g033_hdiv.c n32g033_i2c.c n32g033_iwdg.c n32g033_opamp.c n32g033_pwr.c n32g033_rcc.c n32g033_spi.c n32g033_sqrt.c n32g033_tim.c n32g033_uart.c
  group USER
    ./USER/src/: main.c
  group DVI
    ./DVI/src/: dri_adc.c dri_dog.c dri_flash.c dri_gpio.c dri_timer.c
    ./USER/src/: dri_pvd.c dri_uart.c dri_uart2.c keelop_crc.c
  group INT
    ./USER/src/: n32g033_it.c it_433.c it_adc.c it_exit.c it_timer.c
  group APP
    ./USER/src/: app_433.c app_adc.c app_buzz.c app_flash.c app_led.c app_limt.c app_motor.c app_uart.c app_uart2.c
  group Head
    ./USER/inc/: ALL.h h_433.h H_ALL.h h_tim.h h_uart.h
  group New Group
    ./: readme.txt
